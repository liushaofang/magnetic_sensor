# IAR project TDS_Led.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2272 MSP430F2272
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CONFIG_TMS_END
  ICC430.newCCIncludePaths: ..\system\src\sgr_def; ..\system\src\bsp; ..\system\src\mrfi
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group source/app
    ../system/src/app/: TDSLed.c
  group source/bsp
    ../system/src/bsp/: BspDef.c Flash.c Led.c TimerB.c Uart.c
  group source/mrfi
    ../system/src/mrfi/: mrfi.c mrfi_spi.c
